# Keil uVision project WinOS.uvprojx, settings and files
target WindOS (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WinOS
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT = 1,__FPU_USED=1
  c include: .\_06_Library\Start;.\_01_App;.\_02_User;.\_03_WindOS;.\_04_System;.\_04_System;.\_06_Library\inc;.\_05_Drive;.\_05_Drive\_01_Peripherals;.\_05_Drive\_01_Peripherals\_01_AlientekTFT;.\_08_Material;.\_01_App\APP_MP3\wav;.\_01_App\APP_MP3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xe0000
  memory RVCT10: RAM 0x10000000 size 0x7d00
  group App
    ./_01_App/: App_Flash.c App_LED.c App_CPUMonitor.c App_ReadScreenID.c App_Draw.c App_FPSTest.c App_MP3.c
  group User
    ./_02_User/: main.c User_Library.h
  group WindOS
    ./_03_WindOS/: OS_Manage.c OS_Run.c OS_UI.c OS_StartFile.c OS_Desktop.c OS_Button.c
  group System
    ./_04_System/: delay.c my_sys.c
  group Drive
    ./_05_Drive/: Drive_Exti.c Drive_Interrupt.c Drive_Timer.c Drive_GPIO.c Drive_Flash.c
    ./_05_Drive/_01_Peripherals/: Drive_Touch.c
  group Library
    ./_06_Library/Start/: startup_stm32f40_41xxx.s arm_cortexM4lf_math.lib stm32f4xx_it.c system_stm32f4xx.c
    ./_06_Library/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_flash.c
  group Doc
    ./_07_Doc/: 说明.txt 暂存.txt 常用实例.txt
  group TFT
    ./_05_Drive/_01_Peripherals/_01_AlientekTFT/: ctiic.c diskio.c exfuns.c fattester.c ff.c fontupd.c gt9147.c lcd.c mycc936.c ott2001a.c sdio_sdcard.c spi.c text.c touch.c w25qxx.c 24cxx.c malloc.c myiic.c sys.c usart.c
  group Material
    ./_08_Material/: Material.h
    ./_08_Material/Desk/: Desk_Smile_240x320.c Desk_ScienceFiction_240x320.c Desk_WindRises_240x320.c
    ./_08_Material/Ico/: IcoDefault.c IcoLED.c IcoDrawing.c IcoReadScreenID.c IcoCPU.c IcoFlash.c IcoFPS.c IcoMp3.c
  group AppMP3
    ./_01_App/APP_MP3/: audioplay.c wm8978.c i2s.c
    ./_01_App/APP_MP3/wav/: wavplay.c
